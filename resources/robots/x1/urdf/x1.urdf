Commit message: add hi robot

File: resources/robots/x1/urdf/x1.urdf (robot description, URDF)
Before this commit: robot x1, 58 links, 57 joints
Links:
- link base_link: geometry collision box size=0.2 0.2 0.2; visual mesh filename=../meshes/base_link_simple.STL
